SRC_URI += "file://bsp.cfg \
            file://user_2019-11-23-13-00-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
